<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>vllink_lite_dfu</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>262</archiveVersion>
            <data>
                <version>262</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>3</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.6.2</cstat_version>
                    <checks_tree>
                        <package enabled="true" name="STDCHECKS">
                            <group enabled="true" name="ARR">
                                <check enabled="true" name="ARR-inv-index-pos" />
                                <check enabled="true" name="ARR-inv-index-ptr-pos" />
                                <check enabled="true" name="ARR-inv-index-ptr" />
                                <check enabled="true" name="ARR-inv-index" />
                                <check enabled="true" name="ARR-neg-index" />
                                <check enabled="true" name="ARR-uninit-index" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check enabled="true" name="ATH-cmp-float" />
                                <check enabled="true" name="ATH-cmp-unsign-neg" />
                                <check enabled="true" name="ATH-cmp-unsign-pos" />
                                <check enabled="true" name="ATH-div-0-assign" />
                                <check enabled="false" name="ATH-div-0-cmp-aft" />
                                <check enabled="true" name="ATH-div-0-cmp-bef" />
                                <check enabled="true" name="ATH-div-0-interval" />
                                <check enabled="true" name="ATH-div-0-pos" />
                                <check enabled="true" name="ATH-div-0-unchk-global" />
                                <check enabled="true" name="ATH-div-0-unchk-local" />
                                <check enabled="true" name="ATH-div-0-unchk-param" />
                                <check enabled="true" name="ATH-div-0" />
                                <check enabled="true" name="ATH-inc-bool" />
                                <check enabled="true" name="ATH-malloc-overrun" />
                                <check enabled="true" name="ATH-neg-check-nonneg" />
                                <check enabled="true" name="ATH-neg-check-pos" />
                                <check enabled="true" name="ATH-new-overrun" />
                                <check enabled="false" name="ATH-overflow-cast" />
                                <check enabled="true" name="ATH-overflow" />
                                <check enabled="true" name="ATH-shift-bounds" />
                                <check enabled="true" name="ATH-shift-neg" />
                                <check enabled="true" name="ATH-sizeof-by-sizeof" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check enabled="false" name="CAST-old-style" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check enabled="true" name="CATCH-object-slicing" />
                                <check enabled="false" name="CATCH-xtor-bad-member" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check enabled="false" name="COMMA-overload" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check enabled="true" name="COMMENT-nested" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check enabled="true" name="CONST-member-ret" />
                            </group>
                            <group enabled="true" name="COP">
                                <check enabled="false" name="COP-alloc-ctor" />
                                <check enabled="true" name="COP-assign-op-ret" />
                                <check enabled="true" name="COP-assign-op-self" />
                                <check enabled="true" name="COP-assign-op" />
                                <check enabled="true" name="COP-copy-ctor" />
                                <check enabled="false" name="COP-dealloc-dtor" />
                                <check enabled="true" name="COP-dtor-throw" />
                                <check enabled="true" name="COP-dtor" />
                                <check enabled="true" name="COP-init-order" />
                                <check enabled="true" name="COP-init-uninit" />
                                <check enabled="true" name="COP-member-uninit" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check enabled="true" name="CPU-ctor-call-virt" />
                                <check enabled="false" name="CPU-ctor-implicit" />
                                <check enabled="true" name="CPU-delete-throw" />
                                <check enabled="true" name="CPU-delete-void" />
                                <check enabled="true" name="CPU-dtor-call-virt" />
                                <check enabled="true" name="CPU-malloc-class" />
                                <check enabled="true" name="CPU-nonvirt-dtor" />
                                <check enabled="true" name="CPU-return-ref-to-class-data" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check enabled="false" name="DECL-implicit-int" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check enabled="true" name="DEFINE-hash-multiple" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check enabled="false" name="ENUM-bounds" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check enabled="true" name="EXP-cond-assign" />
                                <check enabled="true" name="EXP-dangling-else" />
                                <check enabled="true" name="EXP-loop-exit" />
                                <check enabled="false" name="EXP-main-ret-int" />
                                <check enabled="false" name="EXP-null-stmt" />
                                <check enabled="false" name="EXP-stray-semicolon" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check enabled="true" name="EXPR-const-overflow" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check enabled="true" name="FPT-cmp-null" />
                                <check enabled="false" name="FPT-literal" />
                                <check enabled="true" name="FPT-misuse" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check enabled="false" name="FUNC-implicit-decl" />
                                <check enabled="false" name="FUNC-unprototyped-all" />
                                <check enabled="true" name="FUNC-unprototyped-used" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check enabled="false" name="INCLUDE-c-file" />
                            </group>
                            <group enabled="true" name="INT">
                                <check enabled="false" name="INT-use-signed-as-unsigned-pos" />
                                <check enabled="true" name="INT-use-signed-as-unsigned" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check enabled="true" name="ITR-end-cmp-aft" />
                                <check enabled="true" name="ITR-end-cmp-bef" />
                                <check enabled="true" name="ITR-invalidated" />
                                <check enabled="false" name="ITR-mismatch-alg" />
                                <check enabled="false" name="ITR-store" />
                                <check enabled="true" name="ITR-uninit" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check enabled="false" name="LIB-bsearch-overrun-pos" />
                                <check enabled="false" name="LIB-bsearch-overrun" />
                                <check enabled="false" name="LIB-fn-unsafe" />
                                <check enabled="false" name="LIB-fread-overrun-pos" />
                                <check enabled="true" name="LIB-fread-overrun" />
                                <check enabled="false" name="LIB-memchr-overrun-pos" />
                                <check enabled="true" name="LIB-memchr-overrun" />
                                <check enabled="false" name="LIB-memcpy-overrun-pos" />
                                <check enabled="true" name="LIB-memcpy-overrun" />
                                <check enabled="false" name="LIB-memset-overrun-pos" />
                                <check enabled="true" name="LIB-memset-overrun" />
                                <check enabled="false" name="LIB-putenv" />
                                <check enabled="false" name="LIB-qsort-overrun-pos" />
                                <check enabled="false" name="LIB-qsort-overrun" />
                                <check enabled="true" name="LIB-return-const" />
                                <check enabled="true" name="LIB-return-error" />
                                <check enabled="true" name="LIB-return-leak" />
                                <check enabled="true" name="LIB-return-neg" />
                                <check enabled="true" name="LIB-return-null" />
                                <check enabled="false" name="LIB-sprintf-overrun" />
                                <check enabled="false" name="LIB-std-sort-overrun-pos" />
                                <check enabled="true" name="LIB-std-sort-overrun" />
                                <check enabled="false" name="LIB-strcat-overrun-pos" />
                                <check enabled="true" name="LIB-strcat-overrun" />
                                <check enabled="false" name="LIB-strcpy-overrun-pos" />
                                <check enabled="true" name="LIB-strcpy-overrun" />
                                <check enabled="false" name="LIB-strncat-overrun-pos" />
                                <check enabled="true" name="LIB-strncat-overrun" />
                                <check enabled="false" name="LIB-strncmp-overrun-pos" />
                                <check enabled="true" name="LIB-strncmp-overrun" />
                                <check enabled="false" name="LIB-strncpy-overrun-pos" />
                                <check enabled="true" name="LIB-strncpy-overrun" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check enabled="false" name="LOGIC-overload" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check enabled="true" name="MEM-delete-array-op" />
                                <check enabled="true" name="MEM-delete-op" />
                                <check enabled="true" name="MEM-double-free-alias" />
                                <check enabled="true" name="MEM-double-free-some" />
                                <check enabled="true" name="MEM-double-free" />
                                <check enabled="true" name="MEM-free-field" />
                                <check enabled="true" name="MEM-free-fptr" />
                                <check enabled="false" name="MEM-free-no-alloc-struct" />
                                <check enabled="false" name="MEM-free-no-alloc" />
                                <check enabled="true" name="MEM-free-no-use" />
                                <check enabled="true" name="MEM-free-op" />
                                <check enabled="true" name="MEM-free-struct-field" />
                                <check enabled="true" name="MEM-free-variable-alias" />
                                <check enabled="true" name="MEM-free-variable" />
                                <check enabled="true" name="MEM-leak-alias" />
                                <check enabled="false" name="MEM-leak" />
                                <check enabled="false" name="MEM-malloc-arith" />
                                <check enabled="true" name="MEM-malloc-diff-type" />
                                <check enabled="true" name="MEM-malloc-sizeof-ptr" />
                                <check enabled="true" name="MEM-malloc-sizeof" />
                                <check enabled="false" name="MEM-malloc-strlen" />
                                <check enabled="true" name="MEM-realloc-diff-type" />
                                <check enabled="true" name="MEM-return-free" />
                                <check enabled="true" name="MEM-return-no-assign" />
                                <check enabled="true" name="MEM-stack-global-field" />
                                <check enabled="true" name="MEM-stack-global" />
                                <check enabled="true" name="MEM-stack-param-ref" />
                                <check enabled="true" name="MEM-stack-param" />
                                <check enabled="true" name="MEM-stack-pos" />
                                <check enabled="true" name="MEM-stack-ref" />
                                <check enabled="true" name="MEM-stack" />
                                <check enabled="true" name="MEM-use-free-all" />
                                <check enabled="true" name="MEM-use-free-some" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check enabled="true" name="PTR-arith-field" />
                                <check enabled="true" name="PTR-arith-stack" />
                                <check enabled="true" name="PTR-arith-var" />
                                <check enabled="true" name="PTR-cmp-str-lit" />
                                <check enabled="false" name="PTR-null-assign-fun-pos" />
                                <check enabled="false" name="PTR-null-assign-pos" />
                                <check enabled="true" name="PTR-null-assign" />
                                <check enabled="true" name="PTR-null-cmp-aft" />
                                <check enabled="true" name="PTR-null-cmp-bef-fun" />
                                <check enabled="true" name="PTR-null-cmp-bef" />
                                <check enabled="true" name="PTR-null-fun-pos" />
                                <check enabled="false" name="PTR-null-literal-pos" />
                                <check enabled="false" name="PTR-overload" />
                                <check enabled="false" name="PTR-singleton-arith-pos" />
                                <check enabled="true" name="PTR-singleton-arith" />
                                <check enabled="true" name="PTR-unchk-param-some" />
                                <check enabled="false" name="PTR-unchk-param" />
                                <check enabled="false" name="PTR-uninit-pos" />
                                <check enabled="true" name="PTR-uninit" />
                            </group>
                            <group enabled="true" name="RED">
                                <check enabled="false" name="RED-alloc-zero-bytes" />
                                <check enabled="false" name="RED-case-reach" />
                                <check enabled="false" name="RED-cmp-always" />
                                <check enabled="false" name="RED-cmp-never" />
                                <check enabled="false" name="RED-cond-always" />
                                <check enabled="true" name="RED-cond-const-assign" />
                                <check enabled="false" name="RED-cond-const-expr" />
                                <check enabled="false" name="RED-cond-const" />
                                <check enabled="false" name="RED-cond-never" />
                                <check enabled="true" name="RED-dead" />
                                <check enabled="false" name="RED-expr" />
                                <check enabled="false" name="RED-func-no-effect" />
                                <check enabled="true" name="RED-local-hides-global" />
                                <check enabled="false" name="RED-local-hides-local" />
                                <check enabled="false" name="RED-local-hides-member" />
                                <check enabled="true" name="RED-local-hides-param" />
                                <check enabled="false" name="RED-no-effect" />
                                <check enabled="true" name="RED-self-assign" />
                                <check enabled="true" name="RED-unused-assign" />
                                <check enabled="false" name="RED-unused-param" />
                                <check enabled="false" name="RED-unused-return-val" />
                                <check enabled="false" name="RED-unused-val" />
                                <check enabled="true" name="RED-unused-var-all" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check enabled="false" name="RESOURCE-deref-file" />
                                <check enabled="true" name="RESOURCE-double-close" />
                                <check enabled="true" name="RESOURCE-file-no-close-all" />
                                <check enabled="false" name="RESOURCE-file-pos-neg" />
                                <check enabled="true" name="RESOURCE-file-use-after-close" />
                                <check enabled="false" name="RESOURCE-implicit-deref-file" />
                                <check enabled="true" name="RESOURCE-write-ronly-file" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check enabled="true" name="SIZEOF-side-effect" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check enabled="true" name="SPC-order" />
                                <check enabled="false" name="SPC-uninit-arr-all" />
                                <check enabled="true" name="SPC-uninit-struct-field-heap" />
                                <check enabled="false" name="SPC-uninit-struct-field" />
                                <check enabled="true" name="SPC-uninit-struct" />
                                <check enabled="true" name="SPC-uninit-var-all" />
                                <check enabled="true" name="SPC-uninit-var-some" />
                                <check enabled="false" name="SPC-volatile-reads" />
                                <check enabled="false" name="SPC-volatile-writes" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check enabled="false" name="STRUCT-signed-bit" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check enabled="true" name="SWITCH-fall-through" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check enabled="false" name="THROW-empty" />
                                <check enabled="false" name="THROW-main" />
                                <check enabled="true" name="THROW-null" />
                                <check enabled="true" name="THROW-ptr" />
                                <check enabled="true" name="THROW-static" />
                                <check enabled="true" name="THROW-unhandled" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check enabled="true" name="UNION-overlap-assign" />
                                <check enabled="true" name="UNION-type-punning" />
                            </group>
                        </package>
                        <package enabled="false" name="CERT">
                            <group enabled="true" name="CERT-EXP">
                                <check enabled="true" name="CERT-EXP19-C" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check enabled="true" name="CERT-FIO37-C" />
                                <check enabled="true" name="CERT-FIO38-C" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check enabled="true" name="CERT-SIG31-C" />
                            </group>
                        </package>
                        <package enabled="false" name="SECURITY">
                            <group enabled="true" name="SEC-BUFFER">
                                <check enabled="true" name="SEC-BUFFER-memory-leak-alias" />
                                <check enabled="false" name="SEC-BUFFER-memory-leak" />
                                <check enabled="false" name="SEC-BUFFER-memset-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-memset-overrun" />
                                <check enabled="false" name="SEC-BUFFER-qsort-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-qsort-overrun" />
                                <check enabled="true" name="SEC-BUFFER-sprintf-overrun" />
                                <check enabled="false" name="SEC-BUFFER-std-sort-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-std-sort-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strcat-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strcat-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strcpy-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strcpy-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strncat-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strncat-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strncmp-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strncmp-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strncpy-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strncpy-overrun" />
                                <check enabled="true" name="SEC-BUFFER-tainted-alloc-size" />
                                <check enabled="true" name="SEC-BUFFER-tainted-copy-length" />
                                <check enabled="true" name="SEC-BUFFER-tainted-copy" />
                                <check enabled="true" name="SEC-BUFFER-tainted-index" />
                                <check enabled="true" name="SEC-BUFFER-tainted-offset" />
                                <check enabled="true" name="SEC-BUFFER-use-after-free-all" />
                                <check enabled="true" name="SEC-BUFFER-use-after-free-some" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check enabled="true" name="SEC-DIV-0-compare-after" />
                                <check enabled="true" name="SEC-DIV-0-compare-before" />
                                <check enabled="true" name="SEC-DIV-0-tainted" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check enabled="true" name="SEC-FILEOP-open-no-close" />
                                <check enabled="false" name="SEC-FILEOP-path-traversal" />
                                <check enabled="true" name="SEC-FILEOP-use-after-close" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check enabled="false" name="SEC-INJECTION-sql" />
                                <check enabled="false" name="SEC-INJECTION-xpath" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check enabled="true" name="SEC-LOOP-tainted-bound" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check enabled="false" name="SEC-NULL-assignment-fun-pos" />
                                <check enabled="true" name="SEC-NULL-assignment" />
                                <check enabled="true" name="SEC-NULL-cmp-aft" />
                                <check enabled="true" name="SEC-NULL-cmp-bef-fun" />
                                <check enabled="true" name="SEC-NULL-cmp-bef" />
                                <check enabled="false" name="SEC-NULL-literal-pos" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check enabled="true" name="SEC-STRING-format-string" />
                                <check enabled="false" name="SEC-STRING-hard-coded-credentials" />
                            </group>
                        </package>
                        <package enabled="false" name="MISRAC2004">
                            <group enabled="true" name="MISRAC2004-1">
                                <check enabled="true" name="MISRAC2004-1.1" />
                                <check enabled="true" name="MISRAC2004-1.2_a" />
                                <check enabled="true" name="MISRAC2004-1.2_b" />
                                <check enabled="true" name="MISRAC2004-1.2_c" />
                                <check enabled="true" name="MISRAC2004-1.2_d" />
                                <check enabled="true" name="MISRAC2004-1.2_e" />
                                <check enabled="true" name="MISRAC2004-1.2_f" />
                                <check enabled="true" name="MISRAC2004-1.2_g" />
                                <check enabled="true" name="MISRAC2004-1.2_h" />
                                <check enabled="true" name="MISRAC2004-1.2_i" />
                                <check enabled="true" name="MISRAC2004-1.2_j" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check enabled="true" name="MISRAC2004-2.1" />
                                <check enabled="true" name="MISRAC2004-2.2" />
                                <check enabled="true" name="MISRAC2004-2.3" />
                                <check enabled="false" name="MISRAC2004-2.4" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check enabled="true" name="MISRAC2004-5.1" />
                                <check enabled="true" name="MISRAC2004-5.2" />
                                <check enabled="true" name="MISRAC2004-5.3" />
                                <check enabled="true" name="MISRAC2004-5.4" />
                                <check enabled="false" name="MISRAC2004-5.5" />
                                <check enabled="false" name="MISRAC2004-5.6" />
                                <check enabled="false" name="MISRAC2004-5.7" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check enabled="true" name="MISRAC2004-6.1" />
                                <check enabled="true" name="MISRAC2004-6.2" />
                                <check enabled="false" name="MISRAC2004-6.3" />
                                <check enabled="true" name="MISRAC2004-6.4" />
                                <check enabled="true" name="MISRAC2004-6.5" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check enabled="true" name="MISRAC2004-7.1" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check enabled="true" name="MISRAC2004-8.1" />
                                <check enabled="true" name="MISRAC2004-8.2" />
                                <check enabled="true" name="MISRAC2004-8.3" />
                                <check enabled="true" name="MISRAC2004-8.5_a" />
                                <check enabled="true" name="MISRAC2004-8.5_b" />
                                <check enabled="true" name="MISRAC2004-8.6" />
                                <check enabled="true" name="MISRAC2004-8.7" />
                                <check enabled="true" name="MISRAC2004-8.8_a" />
                                <check enabled="true" name="MISRAC2004-8.8_b" />
                                <check enabled="true" name="MISRAC2004-8.10" />
                                <check enabled="true" name="MISRAC2004-8.12" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check enabled="true" name="MISRAC2004-9.1_a" />
                                <check enabled="true" name="MISRAC2004-9.1_b" />
                                <check enabled="true" name="MISRAC2004-9.1_c" />
                                <check enabled="true" name="MISRAC2004-9.2" />
                                <check enabled="true" name="MISRAC2004-9.3" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check enabled="true" name="MISRAC2004-10.1_a" />
                                <check enabled="true" name="MISRAC2004-10.1_b" />
                                <check enabled="true" name="MISRAC2004-10.1_c" />
                                <check enabled="true" name="MISRAC2004-10.1_d" />
                                <check enabled="true" name="MISRAC2004-10.2_a" />
                                <check enabled="true" name="MISRAC2004-10.2_b" />
                                <check enabled="true" name="MISRAC2004-10.2_c" />
                                <check enabled="true" name="MISRAC2004-10.2_d" />
                                <check enabled="true" name="MISRAC2004-10.3" />
                                <check enabled="true" name="MISRAC2004-10.4" />
                                <check enabled="true" name="MISRAC2004-10.5" />
                                <check enabled="true" name="MISRAC2004-10.6" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check enabled="true" name="MISRAC2004-11.1" />
                                <check enabled="false" name="MISRAC2004-11.3" />
                                <check enabled="false" name="MISRAC2004-11.4" />
                                <check enabled="true" name="MISRAC2004-11.5" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check enabled="false" name="MISRAC2004-12.1" />
                                <check enabled="true" name="MISRAC2004-12.2_a" />
                                <check enabled="true" name="MISRAC2004-12.2_b" />
                                <check enabled="true" name="MISRAC2004-12.2_c" />
                                <check enabled="true" name="MISRAC2004-12.3" />
                                <check enabled="true" name="MISRAC2004-12.4" />
                                <check enabled="true" name="MISRAC2004-12.5" />
                                <check enabled="false" name="MISRAC2004-12.6_a" />
                                <check enabled="false" name="MISRAC2004-12.6_b" />
                                <check enabled="true" name="MISRAC2004-12.7" />
                                <check enabled="true" name="MISRAC2004-12.8" />
                                <check enabled="true" name="MISRAC2004-12.9" />
                                <check enabled="true" name="MISRAC2004-12.10" />
                                <check enabled="false" name="MISRAC2004-12.11" />
                                <check enabled="true" name="MISRAC2004-12.12_a" />
                                <check enabled="true" name="MISRAC2004-12.12_b" />
                                <check enabled="false" name="MISRAC2004-12.13" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check enabled="true" name="MISRAC2004-13.1" />
                                <check enabled="false" name="MISRAC2004-13.2_a" />
                                <check enabled="false" name="MISRAC2004-13.2_b" />
                                <check enabled="false" name="MISRAC2004-13.2_c" />
                                <check enabled="false" name="MISRAC2004-13.2_d" />
                                <check enabled="false" name="MISRAC2004-13.2_e" />
                                <check enabled="true" name="MISRAC2004-13.3" />
                                <check enabled="true" name="MISRAC2004-13.4" />
                                <check enabled="true" name="MISRAC2004-13.5" />
                                <check enabled="true" name="MISRAC2004-13.6" />
                                <check enabled="true" name="MISRAC2004-13.7_a" />
                                <check enabled="true" name="MISRAC2004-13.7_b" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check enabled="true" name="MISRAC2004-14.1" />
                                <check enabled="true" name="MISRAC2004-14.2" />
                                <check enabled="true" name="MISRAC2004-14.3" />
                                <check enabled="true" name="MISRAC2004-14.4" />
                                <check enabled="true" name="MISRAC2004-14.5" />
                                <check enabled="true" name="MISRAC2004-14.6" />
                                <check enabled="true" name="MISRAC2004-14.7" />
                                <check enabled="true" name="MISRAC2004-14.8_a" />
                                <check enabled="true" name="MISRAC2004-14.8_b" />
                                <check enabled="true" name="MISRAC2004-14.8_c" />
                                <check enabled="true" name="MISRAC2004-14.8_d" />
                                <check enabled="true" name="MISRAC2004-14.9" />
                                <check enabled="true" name="MISRAC2004-14.10" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check enabled="true" name="MISRAC2004-15.0" />
                                <check enabled="true" name="MISRAC2004-15.1" />
                                <check enabled="true" name="MISRAC2004-15.2" />
                                <check enabled="true" name="MISRAC2004-15.3" />
                                <check enabled="true" name="MISRAC2004-15.4" />
                                <check enabled="true" name="MISRAC2004-15.5" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check enabled="true" name="MISRAC2004-16.1" />
                                <check enabled="true" name="MISRAC2004-16.2_a" />
                                <check enabled="true" name="MISRAC2004-16.2_b" />
                                <check enabled="true" name="MISRAC2004-16.3" />
                                <check enabled="true" name="MISRAC2004-16.4" />
                                <check enabled="true" name="MISRAC2004-16.5" />
                                <check enabled="true" name="MISRAC2004-16.7" />
                                <check enabled="true" name="MISRAC2004-16.8" />
                                <check enabled="true" name="MISRAC2004-16.9" />
                                <check enabled="true" name="MISRAC2004-16.10" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check enabled="true" name="MISRAC2004-17.1_a" />
                                <check enabled="true" name="MISRAC2004-17.1_b" />
                                <check enabled="true" name="MISRAC2004-17.1_c" />
                                <check enabled="true" name="MISRAC2004-17.2" />
                                <check enabled="true" name="MISRAC2004-17.3" />
                                <check enabled="true" name="MISRAC2004-17.4_a" />
                                <check enabled="true" name="MISRAC2004-17.4_b" />
                                <check enabled="true" name="MISRAC2004-17.5" />
                                <check enabled="true" name="MISRAC2004-17.6_a" />
                                <check enabled="true" name="MISRAC2004-17.6_b" />
                                <check enabled="true" name="MISRAC2004-17.6_c" />
                                <check enabled="true" name="MISRAC2004-17.6_d" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check enabled="true" name="MISRAC2004-18.1" />
                                <check enabled="true" name="MISRAC2004-18.2" />
                                <check enabled="true" name="MISRAC2004-18.4" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check enabled="false" name="MISRAC2004-19.1" />
                                <check enabled="false" name="MISRAC2004-19.2" />
                                <check enabled="true" name="MISRAC2004-19.4" />
                                <check enabled="true" name="MISRAC2004-19.5" />
                                <check enabled="true" name="MISRAC2004-19.6" />
                                <check enabled="false" name="MISRAC2004-19.7" />
                                <check enabled="true" name="MISRAC2004-19.10" />
                                <check enabled="true" name="MISRAC2004-19.12" />
                                <check enabled="false" name="MISRAC2004-19.13" />
                                <check enabled="true" name="MISRAC2004-19.15" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check enabled="true" name="MISRAC2004-20.1" />
                                <check enabled="true" name="MISRAC2004-20.2" />
                                <check enabled="true" name="MISRAC2004-20.3_a" />
                                <check enabled="true" name="MISRAC2004-20.3_b" />
                                <check enabled="true" name="MISRAC2004-20.3_c" />
                                <check enabled="true" name="MISRAC2004-20.3_d" />
                                <check enabled="true" name="MISRAC2004-20.3_e" />
                                <check enabled="true" name="MISRAC2004-20.3_f" />
                                <check enabled="true" name="MISRAC2004-20.3_g" />
                                <check enabled="true" name="MISRAC2004-20.3_h" />
                                <check enabled="true" name="MISRAC2004-20.3_i" />
                                <check enabled="true" name="MISRAC2004-20.4" />
                                <check enabled="true" name="MISRAC2004-20.5" />
                                <check enabled="true" name="MISRAC2004-20.6" />
                                <check enabled="true" name="MISRAC2004-20.7" />
                                <check enabled="true" name="MISRAC2004-20.8" />
                                <check enabled="true" name="MISRAC2004-20.9" />
                                <check enabled="true" name="MISRAC2004-20.10" />
                                <check enabled="true" name="MISRAC2004-20.11" />
                                <check enabled="true" name="MISRAC2004-20.12" />
                            </group>
                        </package>
                        <package enabled="false" name="MISRAC2012">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check enabled="true" name="MISRAC2012-Dir-4.3" />
                                <check enabled="false" name="MISRAC2012-Dir-4.4" />
                                <check enabled="false" name="MISRAC2012-Dir-4.5" />
                                <check enabled="false" name="MISRAC2012-Dir-4.6_a" />
                                <check enabled="false" name="MISRAC2012-Dir-4.6_b" />
                                <check enabled="false" name="MISRAC2012-Dir-4.7_a" />
                                <check enabled="false" name="MISRAC2012-Dir-4.7_b" />
                                <check enabled="false" name="MISRAC2012-Dir-4.7_c" />
                                <check enabled="false" name="MISRAC2012-Dir-4.8" />
                                <check enabled="false" name="MISRAC2012-Dir-4.9" />
                                <check enabled="true" name="MISRAC2012-Dir-4.10" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_a" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_b" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_c" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_d" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_e" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_f" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_g" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_h" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_i" />
                                <check enabled="false" name="MISRAC2012-Dir-4.12" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_b" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_c" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_d" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_e" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_f" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_g" />
                                <check enabled="false" name="MISRAC2012-Dir-4.13_h" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check enabled="true" name="MISRAC2012-Rule-1.3_a" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_b" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_c" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_d" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_e" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_f" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_g" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_h" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_i" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_j" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_k" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_m" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_n" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_o" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_p" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_q" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_r" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_s" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_t" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_u" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_v" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_w" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check enabled="true" name="MISRAC2012-Rule-2.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-2.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-2.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-2.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-2.2_c" />
                                <check enabled="false" name="MISRAC2012-Rule-2.3" />
                                <check enabled="false" name="MISRAC2012-Rule-2.4" />
                                <check enabled="false" name="MISRAC2012-Rule-2.5" />
                                <check enabled="false" name="MISRAC2012-Rule-2.6" />
                                <check enabled="false" name="MISRAC2012-Rule-2.7" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check enabled="true" name="MISRAC2012-Rule-3.1" />
                                <check enabled="true" name="MISRAC2012-Rule-3.2" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check enabled="true" name="MISRAC2012-Rule-5.1" />
                                <check enabled="true" name="MISRAC2012-Rule-5.2_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.2_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.3_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.3_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.4_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.4_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.5_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.5_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.6" />
                                <check enabled="true" name="MISRAC2012-Rule-5.7" />
                                <check enabled="true" name="MISRAC2012-Rule-5.8" />
                                <check enabled="false" name="MISRAC2012-Rule-5.9" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check enabled="true" name="MISRAC2012-Rule-6.1" />
                                <check enabled="true" name="MISRAC2012-Rule-6.2" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check enabled="true" name="MISRAC2012-Rule-7.1" />
                                <check enabled="true" name="MISRAC2012-Rule-7.2" />
                                <check enabled="true" name="MISRAC2012-Rule-7.3" />
                                <check enabled="true" name="MISRAC2012-Rule-7.4_a" />
                                <check enabled="true" name="MISRAC2012-Rule-7.4_b" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check enabled="true" name="MISRAC2012-Rule-8.1" />
                                <check enabled="true" name="MISRAC2012-Rule-8.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-8.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.3_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.4" />
                                <check enabled="true" name="MISRAC2012-Rule-8.5_a" />
                                <check enabled="true" name="MISRAC2012-Rule-8.5_b" />
                                <check enabled="false" name="MISRAC2012-Rule-8.7" />
                                <check enabled="false" name="MISRAC2012-Rule-8.9_a" />
                                <check enabled="false" name="MISRAC2012-Rule-8.9_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.10" />
                                <check enabled="false" name="MISRAC2012-Rule-8.11" />
                                <check enabled="true" name="MISRAC2012-Rule-8.12" />
                                <check enabled="false" name="MISRAC2012-Rule-8.13" />
                                <check enabled="true" name="MISRAC2012-Rule-8.14" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check enabled="true" name="MISRAC2012-Rule-9.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_c" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_d" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_e" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_f" />
                                <check enabled="true" name="MISRAC2012-Rule-9.2" />
                                <check enabled="true" name="MISRAC2012-Rule-9.3" />
                                <check enabled="true" name="MISRAC2012-Rule-9.4" />
                                <check enabled="true" name="MISRAC2012-Rule-9.5_a" />
                                <check enabled="true" name="MISRAC2012-Rule-9.5_b" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R2" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R3" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R4" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R5" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R6" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R7" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R8" />
                                <check enabled="true" name="MISRAC2012-Rule-10.2" />
                                <check enabled="true" name="MISRAC2012-Rule-10.3" />
                                <check enabled="true" name="MISRAC2012-Rule-10.4_a" />
                                <check enabled="true" name="MISRAC2012-Rule-10.4_b" />
                                <check enabled="false" name="MISRAC2012-Rule-10.5" />
                                <check enabled="true" name="MISRAC2012-Rule-10.6" />
                                <check enabled="true" name="MISRAC2012-Rule-10.7" />
                                <check enabled="true" name="MISRAC2012-Rule-10.8" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check enabled="true" name="MISRAC2012-Rule-11.1" />
                                <check enabled="true" name="MISRAC2012-Rule-11.2" />
                                <check enabled="true" name="MISRAC2012-Rule-11.3" />
                                <check enabled="false" name="MISRAC2012-Rule-11.4" />
                                <check enabled="false" name="MISRAC2012-Rule-11.5" />
                                <check enabled="true" name="MISRAC2012-Rule-11.6" />
                                <check enabled="true" name="MISRAC2012-Rule-11.7" />
                                <check enabled="true" name="MISRAC2012-Rule-11.8" />
                                <check enabled="true" name="MISRAC2012-Rule-11.9" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check enabled="false" name="MISRAC2012-Rule-12.1" />
                                <check enabled="true" name="MISRAC2012-Rule-12.2" />
                                <check enabled="false" name="MISRAC2012-Rule-12.3" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check enabled="true" name="MISRAC2012-Rule-13.1" />
                                <check enabled="true" name="MISRAC2012-Rule-13.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-13.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-13.2_c" />
                                <check enabled="false" name="MISRAC2012-Rule-13.3" />
                                <check enabled="false" name="MISRAC2012-Rule-13.4_a" />
                                <check enabled="false" name="MISRAC2012-Rule-13.4_b" />
                                <check enabled="true" name="MISRAC2012-Rule-13.5" />
                                <check enabled="true" name="MISRAC2012-Rule-13.6" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check enabled="true" name="MISRAC2012-Rule-14.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-14.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-14.2" />
                                <check enabled="true" name="MISRAC2012-Rule-14.3_a" />
                                <check enabled="true" name="MISRAC2012-Rule-14.3_b" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_a" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_b" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_c" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_d" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check enabled="false" name="MISRAC2012-Rule-15.1" />
                                <check enabled="true" name="MISRAC2012-Rule-15.2" />
                                <check enabled="true" name="MISRAC2012-Rule-15.3" />
                                <check enabled="false" name="MISRAC2012-Rule-15.4" />
                                <check enabled="false" name="MISRAC2012-Rule-15.5" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_a" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_b" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_c" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_d" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_e" />
                                <check enabled="true" name="MISRAC2012-Rule-15.7" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check enabled="true" name="MISRAC2012-Rule-16.1" />
                                <check enabled="true" name="MISRAC2012-Rule-16.2" />
                                <check enabled="true" name="MISRAC2012-Rule-16.3" />
                                <check enabled="true" name="MISRAC2012-Rule-16.4" />
                                <check enabled="true" name="MISRAC2012-Rule-16.5" />
                                <check enabled="true" name="MISRAC2012-Rule-16.6" />
                                <check enabled="true" name="MISRAC2012-Rule-16.7" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check enabled="true" name="MISRAC2012-Rule-17.1" />
                                <check enabled="true" name="MISRAC2012-Rule-17.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-17.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-17.3" />
                                <check enabled="true" name="MISRAC2012-Rule-17.4" />
                                <check enabled="false" name="MISRAC2012-Rule-17.5" />
                                <check enabled="true" name="MISRAC2012-Rule-17.6" />
                                <check enabled="true" name="MISRAC2012-Rule-17.7" />
                                <check enabled="false" name="MISRAC2012-Rule-17.8" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check enabled="true" name="MISRAC2012-Rule-18.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-18.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-18.1_c" />
                                <check enabled="true" name="MISRAC2012-Rule-18.1_d" />
                                <check enabled="true" name="MISRAC2012-Rule-18.2" />
                                <check enabled="true" name="MISRAC2012-Rule-18.3" />
                                <check enabled="true" name="MISRAC2012-Rule-18.4" />
                                <check enabled="false" name="MISRAC2012-Rule-18.5" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_a" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_b" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_c" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_d" />
                                <check enabled="true" name="MISRAC2012-Rule-18.7" />
                                <check enabled="true" name="MISRAC2012-Rule-18.8" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check enabled="true" name="MISRAC2012-Rule-19.1" />
                                <check enabled="false" name="MISRAC2012-Rule-19.2" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check enabled="false" name="MISRAC2012-Rule-20.1" />
                                <check enabled="true" name="MISRAC2012-Rule-20.2" />
                                <check enabled="true" name="MISRAC2012-Rule-20.4_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-20.4_c99" />
                                <check enabled="false" name="MISRAC2012-Rule-20.5" />
                                <check enabled="true" name="MISRAC2012-Rule-20.7" />
                                <check enabled="false" name="MISRAC2012-Rule-20.10" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check enabled="true" name="MISRAC2012-Rule-21.1" />
                                <check enabled="true" name="MISRAC2012-Rule-21.2" />
                                <check enabled="true" name="MISRAC2012-Rule-21.3" />
                                <check enabled="true" name="MISRAC2012-Rule-21.4" />
                                <check enabled="true" name="MISRAC2012-Rule-21.5" />
                                <check enabled="true" name="MISRAC2012-Rule-21.6" />
                                <check enabled="true" name="MISRAC2012-Rule-21.7" />
                                <check enabled="true" name="MISRAC2012-Rule-21.8" />
                                <check enabled="true" name="MISRAC2012-Rule-21.9" />
                                <check enabled="true" name="MISRAC2012-Rule-21.10" />
                                <check enabled="true" name="MISRAC2012-Rule-21.11" />
                                <check enabled="false" name="MISRAC2012-Rule-21.12_a" />
                                <check enabled="false" name="MISRAC2012-Rule-21.12_b" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check enabled="true" name="MISRAC2012-Rule-22.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-22.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-22.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-22.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-22.2_c" />
                                <check enabled="true" name="MISRAC2012-Rule-22.3" />
                                <check enabled="true" name="MISRAC2012-Rule-22.4" />
                                <check enabled="true" name="MISRAC2012-Rule-22.5_a" />
                                <check enabled="true" name="MISRAC2012-Rule-22.5_b" />
                                <check enabled="true" name="MISRAC2012-Rule-22.6" />
                            </group>
                        </package>
                        <package enabled="false" name="MISRAC++2008">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check enabled="true" name="MISRAC++2008-0-1-1" />
                                <check enabled="true" name="MISRAC++2008-0-1-2_a" />
                                <check enabled="true" name="MISRAC++2008-0-1-2_b" />
                                <check enabled="true" name="MISRAC++2008-0-1-2_c" />
                                <check enabled="true" name="MISRAC++2008-0-1-3" />
                                <check enabled="true" name="MISRAC++2008-0-1-4_a" />
                                <check enabled="true" name="MISRAC++2008-0-1-4_b" />
                                <check enabled="true" name="MISRAC++2008-0-1-6" />
                                <check enabled="true" name="MISRAC++2008-0-1-7" />
                                <check enabled="false" name="MISRAC++2008-0-1-8" />
                                <check enabled="true" name="MISRAC++2008-0-1-9" />
                                <check enabled="true" name="MISRAC++2008-0-1-11" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check enabled="true" name="MISRAC++2008-0-2-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check enabled="true" name="MISRAC++2008-0-3-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check enabled="true" name="MISRAC++2008-2-7-1" />
                                <check enabled="true" name="MISRAC++2008-2-7-2" />
                                <check enabled="false" name="MISRAC++2008-2-7-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check enabled="true" name="MISRAC++2008-2-10-1" />
                                <check enabled="true" name="MISRAC++2008-2-10-2" />
                                <check enabled="true" name="MISRAC++2008-2-10-3" />
                                <check enabled="true" name="MISRAC++2008-2-10-4" />
                                <check enabled="false" name="MISRAC++2008-2-10-5" />
                                <check enabled="true" name="MISRAC++2008-2-10-6" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check enabled="true" name="MISRAC++2008-2-13-2" />
                                <check enabled="true" name="MISRAC++2008-2-13-3" />
                                <check enabled="true" name="MISRAC++2008-2-13-4_a" />
                                <check enabled="true" name="MISRAC++2008-2-13-4_b" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check enabled="true" name="MISRAC++2008-3-1-1" />
                                <check enabled="true" name="MISRAC++2008-3-1-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check enabled="false" name="MISRAC++2008-3-9-2" />
                                <check enabled="true" name="MISRAC++2008-3-9-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check enabled="true" name="MISRAC++2008-4-5-1" />
                                <check enabled="true" name="MISRAC++2008-4-5-2" />
                                <check enabled="true" name="MISRAC++2008-4-5-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check enabled="true" name="MISRAC++2008-5-0-1_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-1_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-1_c" />
                                <check enabled="false" name="MISRAC++2008-5-0-2" />
                                <check enabled="true" name="MISRAC++2008-5-0-3" />
                                <check enabled="true" name="MISRAC++2008-5-0-4" />
                                <check enabled="true" name="MISRAC++2008-5-0-5" />
                                <check enabled="true" name="MISRAC++2008-5-0-6" />
                                <check enabled="true" name="MISRAC++2008-5-0-7" />
                                <check enabled="true" name="MISRAC++2008-5-0-8" />
                                <check enabled="true" name="MISRAC++2008-5-0-9" />
                                <check enabled="true" name="MISRAC++2008-5-0-10" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_c" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_d" />
                                <check enabled="true" name="MISRAC++2008-5-0-14" />
                                <check enabled="true" name="MISRAC++2008-5-0-15_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-15_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_c" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_d" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_e" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_f" />
                                <check enabled="true" name="MISRAC++2008-5-0-19" />
                                <check enabled="true" name="MISRAC++2008-5-0-21" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check enabled="true" name="MISRAC++2008-5-2-4" />
                                <check enabled="true" name="MISRAC++2008-5-2-5" />
                                <check enabled="true" name="MISRAC++2008-5-2-6" />
                                <check enabled="true" name="MISRAC++2008-5-2-7" />
                                <check enabled="false" name="MISRAC++2008-5-2-9" />
                                <check enabled="false" name="MISRAC++2008-5-2-10" />
                                <check enabled="true" name="MISRAC++2008-5-2-11_a" />
                                <check enabled="true" name="MISRAC++2008-5-2-11_b" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check enabled="true" name="MISRAC++2008-5-3-1" />
                                <check enabled="true" name="MISRAC++2008-5-3-2_a" />
                                <check enabled="true" name="MISRAC++2008-5-3-2_b" />
                                <check enabled="true" name="MISRAC++2008-5-3-3" />
                                <check enabled="true" name="MISRAC++2008-5-3-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check enabled="true" name="MISRAC++2008-5-8-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check enabled="true" name="MISRAC++2008-5-14-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check enabled="true" name="MISRAC++2008-5-18-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check enabled="false" name="MISRAC++2008-5-19-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check enabled="true" name="MISRAC++2008-6-2-1" />
                                <check enabled="true" name="MISRAC++2008-6-2-2" />
                                <check enabled="false" name="MISRAC++2008-6-2-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check enabled="true" name="MISRAC++2008-6-3-1_a" />
                                <check enabled="true" name="MISRAC++2008-6-3-1_b" />
                                <check enabled="true" name="MISRAC++2008-6-3-1_c" />
                                <check enabled="true" name="MISRAC++2008-6-3-1_d" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check enabled="true" name="MISRAC++2008-6-4-1" />
                                <check enabled="true" name="MISRAC++2008-6-4-2" />
                                <check enabled="true" name="MISRAC++2008-6-4-3" />
                                <check enabled="true" name="MISRAC++2008-6-4-4" />
                                <check enabled="true" name="MISRAC++2008-6-4-5" />
                                <check enabled="true" name="MISRAC++2008-6-4-6" />
                                <check enabled="true" name="MISRAC++2008-6-4-7" />
                                <check enabled="true" name="MISRAC++2008-6-4-8" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check enabled="true" name="MISRAC++2008-6-5-1_a" />
                                <check enabled="true" name="MISRAC++2008-6-5-1_b" />
                                <check enabled="true" name="MISRAC++2008-6-5-2" />
                                <check enabled="true" name="MISRAC++2008-6-5-3" />
                                <check enabled="true" name="MISRAC++2008-6-5-4" />
                                <check enabled="true" name="MISRAC++2008-6-5-5" />
                                <check enabled="true" name="MISRAC++2008-6-5-6" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check enabled="true" name="MISRAC++2008-6-6-1" />
                                <check enabled="true" name="MISRAC++2008-6-6-2" />
                                <check enabled="true" name="MISRAC++2008-6-6-4" />
                                <check enabled="true" name="MISRAC++2008-6-6-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check enabled="true" name="MISRAC++2008-7-1-1" />
                                <check enabled="true" name="MISRAC++2008-7-1-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check enabled="true" name="MISRAC++2008-7-2-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check enabled="true" name="MISRAC++2008-7-4-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check enabled="true" name="MISRAC++2008-7-5-1_a" />
                                <check enabled="true" name="MISRAC++2008-7-5-1_b" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_a" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_b" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_c" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_d" />
                                <check enabled="false" name="MISRAC++2008-7-5-4_a" />
                                <check enabled="false" name="MISRAC++2008-7-5-4_b" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check enabled="true" name="MISRAC++2008-8-0-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check enabled="true" name="MISRAC++2008-8-4-1" />
                                <check enabled="true" name="MISRAC++2008-8-4-3" />
                                <check enabled="true" name="MISRAC++2008-8-4-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check enabled="true" name="MISRAC++2008-8-5-1_a" />
                                <check enabled="true" name="MISRAC++2008-8-5-1_b" />
                                <check enabled="true" name="MISRAC++2008-8-5-1_c" />
                                <check enabled="true" name="MISRAC++2008-8-5-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check enabled="true" name="MISRAC++2008-9-3-1" />
                                <check enabled="true" name="MISRAC++2008-9-3-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check enabled="true" name="MISRAC++2008-9-5-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check enabled="true" name="MISRAC++2008-9-6-2" />
                                <check enabled="true" name="MISRAC++2008-9-6-3" />
                                <check enabled="true" name="MISRAC++2008-9-6-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check enabled="true" name="MISRAC++2008-12-1-1_a" />
                                <check enabled="true" name="MISRAC++2008-12-1-1_b" />
                                <check enabled="true" name="MISRAC++2008-12-1-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check enabled="false" name="MISRAC++2008-15-0-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check enabled="true" name="MISRAC++2008-15-1-2" />
                                <check enabled="true" name="MISRAC++2008-15-1-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check enabled="true" name="MISRAC++2008-15-3-1" />
                                <check enabled="false" name="MISRAC++2008-15-3-2" />
                                <check enabled="true" name="MISRAC++2008-15-3-3" />
                                <check enabled="true" name="MISRAC++2008-15-3-4" />
                                <check enabled="true" name="MISRAC++2008-15-3-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check enabled="true" name="MISRAC++2008-15-5-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check enabled="true" name="MISRAC++2008-16-0-3" />
                                <check enabled="true" name="MISRAC++2008-16-0-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check enabled="true" name="MISRAC++2008-16-2-2" />
                                <check enabled="true" name="MISRAC++2008-16-2-3" />
                                <check enabled="true" name="MISRAC++2008-16-2-4" />
                                <check enabled="false" name="MISRAC++2008-16-2-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check enabled="true" name="MISRAC++2008-16-3-1" />
                                <check enabled="false" name="MISRAC++2008-16-3-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check enabled="true" name="MISRAC++2008-17-0-1" />
                                <check enabled="true" name="MISRAC++2008-17-0-3" />
                                <check enabled="true" name="MISRAC++2008-17-0-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check enabled="true" name="MISRAC++2008-18-0-1" />
                                <check enabled="true" name="MISRAC++2008-18-0-2" />
                                <check enabled="true" name="MISRAC++2008-18-0-3" />
                                <check enabled="true" name="MISRAC++2008-18-0-4" />
                                <check enabled="true" name="MISRAC++2008-18-0-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check enabled="true" name="MISRAC++2008-18-2-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check enabled="true" name="MISRAC++2008-18-4-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check enabled="true" name="MISRAC++2008-18-7-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check enabled="true" name="MISRAC++2008-19-3-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check enabled="true" name="MISRAC++2008-27-0-1" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>project</name>
        <group>
            <name>config</name>
            <file>
                <name>$PROJ_DIR$\config\brd_cfg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\brd_cfg_vllink_lite_r3.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\chip_cfg_f350.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\proj_cfg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\proj_cfg_vllink_lite.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\vsf_usr_cfg.h</name>
            </file>
        </group>
        <file>
            <name>$PROJ_DIR$\compile_definitions.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\gd32f350x8_boot.icf</name>
        </file>
        <file>
            <name>$PROJ_DIR$\main.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\usrapp_usbd_common.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\usrapp_usbd_common.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\vsf_dfu.c</name>
        </file>
    </group>
    <group>
        <name>vsf</name>
        <group>
            <name>component</name>
            <group>
                <name>crypto</name>
                <group>
                    <name>hash</name>
                    <group>
                        <name>crc</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\crypto\hash\crc\vsf_crc.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\crypto\hash\crc\vsf_crc.h</name>
                        </file>
                    </group>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\crypto\vsf_crypto_cfg.h</name>
                </file>
            </group>
            <group>
                <name>debugger</name>
                <group>
                    <name>nulink</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\debugger\nulink\NuConsole.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\debugger\nulink\NuConsole.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\debugger\nulink\NuConsole_Config.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\debugger\nulink\NuConsole_stream.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\debugger\nulink\NuConsole_stream.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\debugger\vsf_debugger.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\debugger\vsf_debugger_cfg.h</name>
                </file>
            </group>
            <group>
                <name>fs</name>
                <group>
                    <name>driver</name>
                    <group>
                        <name>fatfs</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\fatfs\vsf_fatfs.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\fatfs\vsf_fatfs.h</name>
                        </file>
                    </group>
                    <group>
                        <name>malfs</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\malfs\vsf_malfs.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\malfs\vsf_malfs.h</name>
                        </file>
                    </group>
                    <group>
                        <name>memfs</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\memfs\vsf_memfs.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\memfs\vsf_memfs.h</name>
                        </file>
                    </group>
                    <group>
                        <name>winfs</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\winfs\vsf_winfs.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\fs\driver\winfs\vsf_winfs.h</name>
                        </file>
                    </group>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\fs\vsf_fs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\fs\vsf_fs.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\fs\vsf_fs_cfg.h</name>
                </file>
            </group>
            <group>
                <name>input</name>
                <group>
                    <name>driver</name>
                    <group>
                        <name>hid</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\input\driver\hid\vsf_input_hid.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\input\driver\hid\vsf_input_hid.h</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>protocol</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\input\protocol\vsf_input_gamepad.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\input\protocol\vsf_input_keyboard.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\input\protocol\vsf_input_mouse.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\input\protocol\vsf_input_sensor.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\input\protocol\vsf_input_touchscreen.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\input\vsf_input.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\input\vsf_input.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\input\vsf_input_cfg.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\input\vsf_input_get_type.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\input\vsf_input_get_type_1bit.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\input\vsf_input_get_type_4bit.h</name>
                </file>
            </group>
            <group>
                <name>mal</name>
                <group>
                    <name>driver</name>
                    <group>
                        <name>fakefat32_mal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\fakefat32_mal\vsf_fakefat32_mal.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\fakefat32_mal\vsf_fakefat32_mal.h</name>
                        </file>
                    </group>
                    <group>
                        <name>file_mal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\file_mal\vsf_file_mal.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\file_mal\vsf_file_mal.h</name>
                        </file>
                    </group>
                    <group>
                        <name>mem_mal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\mem_mal\vsf_mem_mal.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\mem_mal\vsf_mem_mal.h</name>
                        </file>
                    </group>
                    <group>
                        <name>mim_mal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\mim_mal\vsf_mim_mal.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\mim_mal\vsf_mim_mal.h</name>
                        </file>
                    </group>
                    <group>
                        <name>scsi_mal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\scsi_mal\vsf_scsi_mal.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\mal\driver\scsi_mal\vsf_scsi_mal.h</name>
                        </file>
                    </group>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\mal\vsf_mal.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\mal\vsf_mal.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\mal\vsf_mal_cfg.h</name>
                </file>
            </group>
            <group>
                <name>scsi</name>
                <group>
                    <name>drvier</name>
                    <group>
                        <name>mal_scsi</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\scsi\driver\mal_scsi\vsf_mal_scsi.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\scsi\driver\mal_scsi\vsf_mal_scsi.h</name>
                        </file>
                    </group>
                    <group>
                        <name>virtual_scsi</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\scsi\driver\virtual_scsi\vsf_virtual_scsi.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\scsi\driver\virtual_scsi\vsf_virtual_scsi.h</name>
                        </file>
                    </group>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\scsi\vsf_scsi.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\scsi\vsf_scsi.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\scsi\vsf_scsi_cfg.h</name>
                </file>
            </group>
            <group>
                <name>tcpip</name>
                <group>
                    <name>netdrv</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\tcpip\netdrv\vsf_netdrv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\tcpip\netdrv\vsf_netdrv.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\tcpip\vsf_tcpip_cfg.h</name>
                </file>
            </group>
            <group>
                <name>ui</name>
                <group>
                    <name>disp_drv</name>
                    <group>
                        <name>sdl2</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\disp_drv\sdl2\vsf_disp_drv_sdl2.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\disp_drv\sdl2\vsf_disp_drv_sdl2.h</name>
                        </file>
                    </group>
                    <group>
                        <name>usbd_uvc</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\disp_drv\usbd_uvc\vsf_disp_drv_usbd_uvc.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\disp_drv\usbd_uvc\vsf_disp_drv_usbd_uvc.h</name>
                        </file>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\disp_drv\vsf_disp_drv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\disp_drv\vsf_disp_drv.h</name>
                    </file>
                </group>
                <group>
                    <name>tgui</name>
                    <group>
                        <name>gui_mc</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\__vsf_tgui_mc_common.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_msg_tree_cfg.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_button.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_button.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_control.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_control.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_label.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_label.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_list.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_list.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_mc.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_mc.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_panel.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_panel.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_text_list.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_mc\vsf_tgui_text_list.h</name>
                        </file>
                    </group>
                    <group>
                        <name>gui_v</name>
                        <group>
                            <name>simple_view</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_button.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_button.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_container.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_container.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_control.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_control.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_draw.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_draw.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_label.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_label.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_list.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_list.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_panel.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_panel.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_port.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_style.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_style.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_text_list.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_sv_text_list.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_v_template.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\simple_view\vsf_tgui_v_type.h</name>
                            </file>
                        </group>
                        <group>
                            <name>template</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_button.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_button.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_container.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_container.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_control.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_control.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_label.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_label.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_panel.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_panel.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_template.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\template\vsf_tgui_v_type.h</name>
                            </file>
                        </group>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\vsf_tgui_v.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\gui_v\vsf_tgui_v.h</name>
                        </file>
                    </group>
                    <group>
                        <name>utilities</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\utilities\vsf_tgui_color.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\utilities\vsf_tgui_color.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\utilities\vsf_tgui_font.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\utilities\vsf_tgui_font.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\utilities\vsf_tgui_text.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\utilities\vsf_tgui_text.h</name>
                        </file>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\vsf_tgui.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\vsf_tgui.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\vsf_tgui_cfg.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\vsf_tgui_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\ui\tgui\vsf_tgui_common.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\ui\vsf_ui_cfg.h</name>
                </file>
            </group>
            <group>
                <name>usb</name>
                <group>
                    <name>common</name>
                    <group>
                        <name>class</name>
                        <group>
                            <name>CDC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\common\class\CDC\vsf_usb_CDC.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\common\class\CDC\vsf_usb_CDCACM.h</name>
                            </file>
                        </group>
                        <group>
                            <name>HID</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\common\class\HID\vsf_usb_HID.h</name>
                            </file>
                        </group>
                        <group>
                            <name>HUB</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\common\class\HUB\vsf_usb_HUB.h</name>
                            </file>
                        </group>
                        <group>
                            <name>MSC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\common\class\MSC\vsf_usb_MSC.h</name>
                            </file>
                        </group>
                        <group>
                            <name>UVC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\common\class\UVC\vsf_usb_UVC.h</name>
                            </file>
                        </group>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\usb\common\usb_common.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\usb\common\usb_desc.h</name>
                    </file>
                </group>
                <group>
                    <name>device</name>
                    <group>
                        <name>class</name>
                        <group>
                            <name>CDC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\CDC\vsf_usbd_CDC.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\CDC\vsf_usbd_CDC.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\CDC\vsf_usbd_CDCACM.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\CDC\vsf_usbd_CDCACM.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\CDC\vsf_usbd_CDCACM_desc.h</name>
                            </file>
                        </group>
                        <group>
                            <name>HID</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\HID\vsf_usbd_HID.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\HID\vsf_usbd_HID.h</name>
                            </file>
                        </group>
                        <group>
                            <name>MSC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\MSC\vsf_usbd_MSC.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\MSC\vsf_usbd_MSC.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\MSC\vsf_usbd_MSC_desc.h</name>
                            </file>
                        </group>
                        <group>
                            <name>UVC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\UVC\vsf_usbd_UVC.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\device\class\UVC\vsf_usbd_UVC.h</name>
                            </file>
                        </group>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\usb\device\vsf_usbd.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\usb\device\vsf_usbd.h</name>
                    </file>
                </group>
                <group>
                    <name>driver</name>
                    <group>
                        <name>dcd</name>
                        <group>
                            <name>usbip_dcd</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\dcd\usbip_dcd\vsf_usbip_dcd.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\dcd\usbip_dcd\vsf_usbip_dcd.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>hcd</name>
                        <group>
                            <name>libusb_hcd</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\hcd\libusb_hcd\vsf_libusb_hcd.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\hcd\libusb_hcd\vsf_libusb_hcd.h</name>
                            </file>
                        </group>
                        <group>
                            <name>ohci</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\hcd\ohci\vsf_ohci.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\hcd\ohci\vsf_ohci.h</name>
                            </file>
                        </group>
                        <group>
                            <name>winusb_hcd</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\hcd\winusb_hcd\vsf_winusb_hcd.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\hcd\winusb_hcd\vsf_winusb_hcd.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>otg</name>
                        <group>
                            <name>dwcotg</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\dwcotg\dwcotg_regs.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\dwcotg\vsf_dwcotg_common.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\dwcotg\vsf_dwcotg_common.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\dwcotg\vsf_dwcotg_dcd.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\dwcotg\vsf_dwcotg_dcd.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\dwcotg\vsf_dwcotg_hw.h</name>
                            </file>
                        </group>
                        <group>
                            <name>musb</name>
                            <group>
                                <name>fdrc</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\musb\fdrc\__vsf_musb_fdrc_common.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\musb\fdrc\__vsf_musb_fdrc_common.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\musb\fdrc\vsf_musb_fdrc_dcd.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\component\usb\driver\otg\musb\fdrc\vsf_musb_fdrc_dcd.h</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
                <group>
                    <name>host</name>
                    <group>
                        <name>class</name>
                        <group>
                            <name>BTHCI</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\BTHCI\vsf_usbh_BTHCI.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\BTHCI\vsf_usbh_BTHCI.h</name>
                            </file>
                        </group>
                        <group>
                            <name>CDC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\CDC\vsf_usbh_CDC.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\CDC\vsf_usbh_CDC.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\CDC\vsf_usbh_CDCECM.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\CDC\vsf_usbh_CDCECM.h</name>
                            </file>
                        </group>
                        <group>
                            <name>HID</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\HID\vsf_usbh_HID.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\HID\vsf_usbh_HID.h</name>
                            </file>
                        </group>
                        <group>
                            <name>HUB</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\HUB\vsf_usbh_HUB.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\HUB\vsf_usbh_HUB.h</name>
                            </file>
                        </group>
                        <group>
                            <name>libusb</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\libusb\vsf_usbh_libusb.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\libusb\vsf_usbh_libusb.h</name>
                            </file>
                        </group>
                        <group>
                            <name>MSC</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\MSC\vsf_usbh_msc.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\component\usb\host\class\MSC\vsf_usbh_msc.h</name>
                            </file>
                        </group>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\usb\host\vsf_usbh.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\component\usb\host\vsf_usbh.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\component\usb\vsf_usb_cfg.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\component\vsf_component.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\component\vsf_component.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\component\vsf_component_cfg.h</name>
            </file>
        </group>
        <group>
            <name>hal</name>
            <group>
                <name>arch</name>
                <group>
                    <name>arm</name>
                    <group>
                        <name>cortex-m</name>
                        <group>
                            <name>SysTick</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\SysTick\i_io_systick.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\SysTick\systick.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\SysTick\systick.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\SysTick\systick_internal.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\SysTick\systick_internal.h</name>
                            </file>
                        </group>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\cortex_m_generic.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\hal\arch\arm\cortex-m\cortex_m_generic.h</name>
                        </file>
                    </group>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\arch\__vsf_arch_interface.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\arch\vsf_arch.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\arch\vsf_arch_abstraction.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\arch\vsf_arch_abstraction.h</name>
                </file>
            </group>
            <group>
                <name>driver</name>
                <group>
                    <name>GigaDevice</name>
                    <group>
                        <name>GD32F3X0</name>
                        <group>
                            <name>common</name>
                            <group>
                                <name>usb</name>
                                <group>
                                    <name>dc</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\dc\usbd.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\dc\usbd.h</name>
                                    </file>
                                </group>
                                <group>
                                    <name>hc</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\hc\usbh.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\hc\usbh.h</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\usb.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\usb.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\usb_common.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usb\usb_lv0.c</name>
                                </file>
                            </group>
                            <group>
                                <name>vendor</name>
                                <group>
                                    <name>Include</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_adc.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_cec.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_cmp.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_crc.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_ctc.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_dac.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_dbg.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_dma.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_exti.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_fmc.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_fwdgt.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_gpio.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_i2c.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_misc.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_pmu.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_rcu.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_rtc.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_spi.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_syscfg.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_timer.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_tsi.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_usart.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\vendor\Include\gd32f3x0_wwdgt.h</name>
                                    </file>
                                </group>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\__common.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\__common.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\delay.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\delay.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\flash.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\flash_lv0.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\io.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\io_lv0.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\jtag.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\jtag.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\startup_GD32F3X0.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\swd.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\swd.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usart.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\common\usart_lv0.c</name>
                            </file>
                        </group>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\__device.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\device.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\driver.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\GD32F3X0\driver.h</name>
                        </file>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\hal\driver\GigaDevice\driver.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\driver\driver.h</name>
                </file>
            </group>
            <group>
                <name>interface</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\interface\vsf_interface_common.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\interface\vsf_interface_io.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\interface\vsf_interface_pm.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\interface\vsf_interface_usart.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\hal\interface\vsf_interface_usb.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\hal\vsf_hal.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\hal\vsf_hal.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\hal\vsf_hal_cfg.h</name>
            </file>
        </group>
        <group>
            <name>kernel</name>
            <group>
                <name>__eda</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\__eda\vsf_eda_bmpevt.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\__eda\vsf_eda_queue.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\__eda\vsf_eda_sync.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\__eda\vsf_eda_timer.c</name>
                </file>
            </group>
            <group>
                <name>lib</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\lib\__kernel_lib_with_full_feature_set.h</name>
                </file>
            </group>
            <group>
                <name>shell</name>
                <group>
                    <name>simple</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\kernel\shell\simple\vsf_simple.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\kernel\shell\simple\vsf_simple_bmevt.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\kernel\shell\simple\vsf_simple_bmevt.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\kernel\shell\simple\vsf_simple_task.c</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\shell\vsf_shell.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\shell\vsf_shell.h</name>
                </file>
            </group>
            <group>
                <name>task</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\__vsf_task_common.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\vsf_fsm.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\vsf_pt.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\vsf_task.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\vsf_task.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\vsf_thread.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\kernel\task\vsf_thread.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_eda.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_eda.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_eda_slist_queue.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_eda_slist_queue.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_evtq.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_evtq_array.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_evtq_list.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_kernel.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_kernel_bsp.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_kernel_cfg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_kernel_common.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_os.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_os.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_timq.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\kernel\vsf_timq_dlist.h</name>
            </file>
        </group>
        <group>
            <name>osa_hal</name>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\osa_hal\vsf_osa_hal.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\osa_hal\vsf_osa_hal.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\osa_hal\vsf_osa_hal_cfg.h</name>
            </file>
        </group>
        <group>
            <name>osa_service</name>
            <group>
                <name>msg_tree</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\osa_service\msg_tree\vsf_msg_tree.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\osa_service\msg_tree\vsf_msg_tree.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\osa_service\vsf_osa_service.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\osa_service\vsf_osa_service.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\osa_service\vsf_osa_service_cfg.h</name>
            </file>
        </group>
        <group>
            <name>service</name>
            <group>
                <name>dynarr</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\dynarr\vsf_dynarr.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\dynarr\vsf_dynarr.h</name>
                </file>
            </group>
            <group>
                <name>dystack</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\dynstack\vsf_dynstack.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\dynstack\vsf_dynstack.h</name>
                </file>
            </group>
            <group>
                <name>heap</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\heap\vsf_heap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\heap\vsf_heap.h</name>
                </file>
            </group>
            <group>
                <name>json</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\json\vsf_json.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\json\vsf_json.h</name>
                </file>
            </group>
            <group>
                <name>pbuf</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\pbuf\vsf_pbuf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\pbuf\vsf_pbuf.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\pbuf\vsf_pbuf_pool.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\pbuf\vsf_pbuf_pool.h</name>
                </file>
            </group>
            <group>
                <name>pool</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\pool\vsf_pool.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\pool\vsf_pool.h</name>
                </file>
            </group>
            <group>
                <name>stream</name>
                <group>
                    <name>pbuf_queue</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\service\stream\pbuf_queue\vsf_pbuf_queue.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\service\stream\pbuf_queue\vsf_pbuf_queue.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\interface.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream_base.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream_base.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream_reader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream_reader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream_writer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\stream\vsf_stream_writer.h</name>
                </file>
            </group>
            <group>
                <name>trace</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\trace\vsf_trace.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\trace\vsf_trace.h</name>
                </file>
            </group>
            <group>
                <name>vsfstream</name>
                <group>
                    <name>fifo_steam</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\service\vsfstream\fifo_stream\vsf_fifo_stream.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\service\vsfstream\fifo_stream\vsf_fifo_stream.h</name>
                    </file>
                </group>
                <group>
                    <name>mem_stream</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\service\vsfstream\mem_stream\vsf_mem_stream.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\service\vsfstream\mem_stream\vsf_mem_stream.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\vsfstream\vsfstream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\service\vsfstream\vsfstream.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\service\vsf_service.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\service\vsf_service.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\service\vsf_service_cfg.h</name>
            </file>
        </group>
        <group>
            <name>shell</name>
            <group>
                <name>sys</name>
                <group>
                    <name>linux</name>
                    <group>
                        <name>include</name>
                        <group>
                            <name>linux</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\linux\limits.h</name>
                            </file>
                        </group>
                        <group>
                            <name>sys</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\sys\mount.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\sys\select.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\sys\stat.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\sys\time.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\sys\types.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\sys\wait.h</name>
                            </file>
                        </group>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\dirent.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\errno.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\fcntl.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\libusb.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\poll.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\pthread.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\semaphore.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\signal.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\stdio.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\string.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\termios.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\time.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\unistd.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\include\wchar.h</name>
                        </file>
                    </group>
                    <group>
                        <name>lib</name>
                        <group>
                            <name>glibc</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc_pthread.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc_sem.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc_stdio.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc_stdlib.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc_string.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\glibc\vsf_linux_glibc_time.c</name>
                            </file>
                        </group>
                        <group>
                            <name>libusb</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\lib\libusb\vsf_linux_libusb.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>port</name>
                        <group>
                            <name>busybox</name>
                            <group>
                                <name>shell</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\port\busybox\shell\vsh.c</name>
                                </file>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\port\busybox\busybox.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\port\busybox\busybox.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\port\busybox\config.h</name>
                            </file>
                        </group>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\vsf_linux.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\vsf_linux.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\vsf_linux_cfg.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\shell\sys\linux\vsf_linux_socket.c</name>
                    </file>
                </group>
            </group>
        </group>
        <group>
            <name>utilities</name>
            <group>
                <name>3rd-party</name>
                <group>
                    <name>PLOOC</name>
                    <group>
                        <name>raw</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\utilities\3rd-party\PLOOC\raw\plooc.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\utilities\3rd-party\PLOOC\raw\plooc_class.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\utilities\3rd-party\PLOOC\raw\plooc_class_black_box.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\utilities\3rd-party\PLOOC\raw\plooc_class_simple.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\utilities\3rd-party\PLOOC\raw\plooc_class_simple_c90.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\vsf\utilities\3rd-party\PLOOC\raw\plooc_class_strict.h</name>
                        </file>
                    </group>
                </group>
            </group>
            <group>
                <name>compiler</name>
                <group>
                    <name>__common</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\__common\__compiler.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\__common\__retarget_io.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\__common\__signal.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\__common\__type.h</name>
                    </file>
                </group>
                <group>
                    <name>arm</name>
                    <group>
                        <name>CMSIS</name>
                        <group>
                            <name>Core</name>
                            <group>
                                <name>Include</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_armcc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_armclang.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_armclang_ltm.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_compiler.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_gcc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_iccarm.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\cmsis_version.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_armv81mml.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_armv8mbl.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_armv8mml.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm0.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm0plus.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm1.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm23.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm3.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm33.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm35p.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm4.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_cm7.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_sc000.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\core_sc300.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\mpu_armv7.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\mpu_armv8.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include\tz_context.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>DSP</name>
                            <group>
                                <name>Include</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include\arm_common_tables.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include\arm_const_structs.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include\arm_math.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>NN</name>
                            <group>
                                <name>Include</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include\arm_nn_tables.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include\arm_nnfunctions.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include\arm_nnsupportfunctions.h</name>
                                </file>
                            </group>
                        </group>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\arm_compiler.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\retarget_io.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\signal.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\signal.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\vsf\utilities\compiler\arm\type.h</name>
                    </file>
                </group>
            </group>
            <group>
                <name>language_extension</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\code_region.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\code_region.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\delegate.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\delegate.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\language_extension.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\simple_sprintf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\language_extension\simple_sscanf.c</name>
                </file>
            </group>
            <group>
                <name>preprocessor</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\preprocessor\mf_u8_dec2str.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\preprocessor\mrepeat.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\preprocessor\preprocessor.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\preprocessor\tpaste.h</name>
                </file>
            </group>
            <group>
                <name>template</name>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\template.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\vsf_bitmap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\vsf_bitmap.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\vsf_list.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\vsf_list.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\vsf_queue.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\vsf\utilities\template\vsf_queue.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\utilities\communicate.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\utilities\compiler.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\vsf\utilities\ooc_class.h</name>
            </file>
        </group>
        <file>
            <name>$PROJ_DIR$\..\..\vsf\vsf.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\vsf\vsf_cfg.h</name>
        </file>
    </group>
</project>

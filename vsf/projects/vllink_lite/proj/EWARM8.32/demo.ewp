# IAR project demo.ewp, settings and files
configuration Vllink_Lite_Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350x8 GD GD32F350x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: FLASH_LOAD_OFFSET=0x08003000; BOARD_TYPE_VLLINK_LITE
  ICCARM.CCDiagSuppress: Pa050,Pe301
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\config; ..\..\..\..; ..\..\..\..\hal; ..\..\..\..\hal\compiler\arm; ..\..\..\..\hal\compiler\arm\cmsis\dsp; ..\..\..\..\hal\compiler\arm\cmsis\cortex_m; ..\..\..\..\hal\cpu\gd32f3x0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vllink_lite_app_0x08003000.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: GD32F350x8_booted.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Vllink_Lite_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_LOAD_OFFSET=0x08003000; BOARD_TYPE_VLLINK_LITE
  ICCARM.CCOptLevel: 3
configuration Vllink_Lite_Bootloader_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH_LOAD_OFFSET=0x08000000; BOARD_TYPE_VLLINK_LITE_BOOTLOADER
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkIcfFile: GD32F350xx_bootloader.icf
configuration Vllink_Lite_Bootloader_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_LOAD_OFFSET=0x08000000; BOARD_TYPE_VLLINK_LITE_BOOTLOADER
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vllink_lite_bootloader_12KB.bin
  ILINK.IlinkIcfFile: GD32F350xx_bootloader.icf
  group (top)
    ./: GD32F350x6.icf GD32F350x8.icf GD32F350x8_booted.icf
  group proj
    ../: app_cfg.h proj_cfg.h proj_cfg_vllink_lite.h proj_cfg_vllink_lite_bootloader.h vsf_cfg.h vsfhal_cfg.h vsfhal_cfg_vllink_lite.h vsfhal_cfg_vllink_lite_bootloader.h
  group usrapp
    ../../: usbd_config.c usbd_config_bootloader.c usrapp.c usrapp.h
  group usrapp/protocol/cmsis_dap
    ../../protocol/cmsis_dap/: vsfusbd_CMSIS_DAP.c vsfusbd_CMSIS_DAP.h
  group usrapp/protocol/cmsis_dap_v2
    ../../protocol/cmsis_dap_v2/: vsfusbd_cmsis_dap_v2.c vsfusbd_cmsis_dap_v2.h
  group usrapp/protocol/dap_block
    ../../protocol/dap_block/: DAP.c DAP.h DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group usrapp/protocol/dfu
    ../../protocol/dfu/: vsfusbd_dfu.c vsfusbd_dfu.h
  group usrapp/protocol/webusb
    ../../protocol/webusb/: vsfusbd_webusb.c vsfusbd_webusb.h
  group vsf
    ../../../../: vsf.h vsf_err.h vsf_type.h vsfmain.c
  group vsf/component/debug
    ../../../../component/debug/: vsfdbg.c vsfdbg.h
  group vsf/component/file
    ../../../../component/file/: vsfile.c vsfile.h
  group vsf/component/file/fs/fakefs/fakefat32
    ../../../../component/file/fs/fakefs/fakefat32/: fakefat32.c fakefat32.h
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c vsffat.h
  group vsf/component/fundation/bittool
    ../../../../component/fundation/bittool/: bittool.c bittool.h
  group vsf/component/fundation/buffer
    ../../../../component/fundation/buffer/: buffer.c buffer.h
  group vsf/component/fundation/list
    ../../../../component/fundation/list/: list.c list.h
  group vsf/component/fundation/stream
    ../../../../component/fundation/stream/: stream.c stream.h
  group vsf/component/shell
    ../../../../component/shell/: vsfshell.c vsfshell.h
  group vsf/component/stream/usart_stream
    ../../../../component/stream/usart_stream/: usart_stream.c usart_stream.h
  group vsf/component/tool/dynarr
    ../../../../component/tool/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/component/tool/dynpool
    ../../../../component/tool/dynpool/: vsf_dynpool.c vsf_dynpool.h
  group vsf/component/tool/dynstack
    ../../../../component/tool/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/component/usb/class/common/CDC
    ../../../../component/usb/class/common/CDC/: vsfusb_CDC.h vsfusb_CDCACM.h vsfusb_RNDIS.h
  group vsf/component/usb/class/common/MSC
    ../../../../component/usb/class/common/MSC/: vsfusb_MSC.h
  group vsf/component/usb/class/device/CDC
    ../../../../component/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDC.h vsfusbd_CDCACM.c vsfusbd_CDCACM.h vsfusbd_RNDIS.c vsfusbd_RNDIS.h
  group vsf/component/usb/class/device/HID
    ../../../../component/usb/class/device/HID/: vsfusbd_HID.c vsfusbd_HID.h
  group vsf/component/usb/class/device/MSC
    ../../../../component/usb/class/device/MSC/: vsfusbd_MSC_BOT.c vsfusbd_MSC_BOT.h
  group vsf/component/usb/common
    ../../../../component/usb/common/: usb_ch11.h usb_ch9.h usb_common.c usb_common.h usb_type.h
  group vsf/component/usb/core
    ../../../../component/usb/core/: vsfusbd.c vsfusbd.h
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c vsfsm.h
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c vsftimer.h
  group vsf/hal
    ../../../../hal/: vsfhal.c vsfhal.h
  group vsf/hal/compiler/arm
    ../../../../hal/compiler/arm/: compiler.h
  group vsf/hal/cpu/gd32f3x0
    ../../../../hal/cpu/gd32f3x0/: gd32f3x0.h gd32f3x0_include.h startup_iar_gd32f3x0.s vsf_basetype.h vsfhal_const.h vsfhal_core.c vsfhal_core.h vsfhal_delay.c vsfhal_flash.c vsfhal_gpio.c vsfhal_jtag.c vsfhal_jtag.h vsfhal_swd.c vsfhal_swd.h vsfhal_timer.c vsfhal_usart.c vsfhal_usb.c vsfhal_usb.h

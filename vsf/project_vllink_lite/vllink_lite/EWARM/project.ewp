# IAR project project.ewp, settings and files
configuration VllinkLite_GD32F350 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350x8 GD GD32F350x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: PROJ_CFG_VLLINKLITE; BRD_CFG_VLLINKLITE_GD32F350
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\config; ..\..\..\vsf; ..\..\..\vsf\shell\sys\linux\include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vllink_lite_gd32f350xx_app.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: GD32F350xx_booted.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration VllinkLite_GD32E103 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.FPU2: 4
  ICCARM.CCDefines: PROJ_CFG_VLLINKLITE; BRD_CFG_VLLINKLITE_GD32E103
  OBJCOPY.OOCOutputFile: vllink_lite_gd32e103xx_app.bin
  ILINK.IlinkIcfFile: GD32E103xx_booted.icf
  group project
    ./: GD32E103xx_booted.icf GD32F350xx_booted.icf
    ../: main.c usrapp_usbd_common.c usrapp_usbd_vllinklite.c vsf_usbd_cmsis_dap_v2.c vsf_usbd_cmsis_dap_v2.h vsf_usbd_webusb_usr.h
  group project/config
    ../config/: brd_cfg.h brd_cfg_vllinklite_gd32e103.h brd_cfg_vllinklite_gd32f350.h chip_cfg_gd32e10x.h chip_cfg_gd32f3x0.h proj_cfg.h proj_cfg_vllinklite.h vsf_usr_cfg.h
  group project/dap
    ../dap/: dap.c dap.h dap_swo.c dap_swo.h dap_vendor.c dap_vendor.h
  group project/daphost
    ../daphost/: daphost.c daphost.h daphost_jtag.c daphost_jtag.h daphost_priv.h daphost_swd.c daphost_swd.h
  group project/shell
    ../shell/: extrauart.c extrauart.h help.c help.h
  group vsf
    ../../../vsf/: vsf.h vsf_cfg.h
    ../: vsf_usbd_webusb_usr.c
  group vsf/component
    ../../../vsf/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/crypto
    ../../../vsf/component/crypto/: vsf_crypto_cfg.h
  group vsf/component/crypto/hash/crc
    ../../../vsf/component/crypto/hash/crc/: vsf_crc.c vsf_crc.h
  group vsf/component/debugger
    ../../../vsf/component/debugger/: vsf_debugger.h vsf_debugger_cfg.h
  group vsf/component/debugger/nulink
    ../../../vsf/component/debugger/nulink/: NuConsole_stream.c NuConsole_stream.h
  group vsf/component/debugger/segger_rtt
    ../../../vsf/component/debugger/segger_rtt/: segger_rtt_stream.c segger_rtt_stream.h
  group vsf/component/fs
    ../../../vsf/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group vsf/component/fs/driver/fatfs
    ../../../vsf/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group vsf/component/fs/driver/malfs
    ../../../vsf/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/fs/driver/memfs
    ../../../vsf/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group vsf/component/fs/driver/winfs
    ../../../vsf/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group vsf/component/input
    ../../../vsf/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h vsf_input_get_type.h vsf_input_get_type_1bit.h vsf_input_get_type_4bit.h
  group vsf/component/input/driver/hid
    ../../../vsf/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/input/protocol
    ../../../vsf/component/input/protocol/: vsf_input_gamepad.h vsf_input_keyboard.h vsf_input_mouse.h vsf_input_sensor.h vsf_input_touchscreen.h
  group vsf/component/mal
    ../../../vsf/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group vsf/component/mal/driver/fakefat32_mal
    ../../../vsf/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group vsf/component/mal/driver/file_mal
    ../../../vsf/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group vsf/component/mal/driver/mem_mal
    ../../../vsf/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group vsf/component/mal/driver/mim_mal
    ../../../vsf/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group vsf/component/mal/driver/scsi_mal
    ../../../vsf/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group vsf/component/scsi
    ../../../vsf/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group vsf/component/scsi/drvier/mal_scsi
    ../../../vsf/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group vsf/component/scsi/drvier/virtual_scsi
    ../../../vsf/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group vsf/component/tcpip
    ../../../vsf/component/tcpip/: vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../../vsf/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/ui
    ../../../vsf/component/ui/: vsf_ui_cfg.h
  group vsf/component/usb
    ../../../vsf/component/usb/: vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../vsf/component/usb/common/: usb_common.h usb_desc.h
  group vsf/component/usb/common/class/CDC
    ../../../vsf/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/HID
    ../../../vsf/component/usb/common/class/HID/: vsf_usb_HID.h
  group vsf/component/usb/common/class/HUB
    ../../../vsf/component/usb/common/class/HUB/: vsf_usb_HUB.h
  group vsf/component/usb/common/class/MSC
    ../../../vsf/component/usb/common/class/MSC/: vsf_usb_MSC.h
  group vsf/component/usb/common/class/UVC
    ../../../vsf/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group vsf/component/usb/device
    ../../../vsf/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../../vsf/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h vsf_usbd_CDCACM_desc.h
  group vsf/component/usb/device/class/HID
    ../../../vsf/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/device/class/MSC
    ../../../vsf/component/usb/device/class/MSC/: vsf_usbd_MSC.c vsf_usbd_MSC.h vsf_usbd_MSC_desc.h
  group vsf/component/usb/device/class/UVC
    ../../../vsf/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group vsf/component/usb/driver/dcd/usbip_dcd
    ../../../vsf/component/usb/driver/dcd/usbip_dcd/: vsf_usbip_dcd.c vsf_usbip_dcd.h
  group vsf/component/usb/driver/hcd/libusb_hcd
    ../../../vsf/component/usb/driver/hcd/libusb_hcd/: vsf_libusb_hcd.c vsf_libusb_hcd.h
  group vsf/component/usb/driver/hcd/ohci
    ../../../vsf/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/component/usb/driver/hcd/winusb_hcd
    ../../../vsf/component/usb/driver/hcd/winusb_hcd/: vsf_winusb_hcd.c vsf_winusb_hcd.h
  group vsf/component/usb/driver/otg/dwcotg
    ../../../vsf/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h vsf_dwcotg_hw.h
  group vsf/component/usb/driver/otg/musb/fdrc
    ../../../vsf/component/usb/driver/otg/musb/fdrc/: __vsf_musb_fdrc_common.c __vsf_musb_fdrc_common.h vsf_musb_fdrc_dcd.c vsf_musb_fdrc_dcd.h
  group vsf/component/usb/host
    ../../../vsf/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../../vsf/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../../vsf/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/HID
    ../../../vsf/component/usb/host/class/HID/: vsf_usbh_HID.c vsf_usbh_HID.h
  group vsf/component/usb/host/class/HUB
    ../../../vsf/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/libusb
    ../../../vsf/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/component/usb/host/class/MSC
    ../../../vsf/component/usb/host/class/MSC/: vsf_usbh_msc.c vsf_usbh_msc.h
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../vsf/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/cortex-m
    ../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/SysTick
    ../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../vsf/hal/driver/: driver.h
  group vsf/hal/interface
    ../../../vsf/hal/interface/: vsf_interface_common.h vsf_interface_io.h vsf_interface_pm.h vsf_interface_usart.h vsf_interface_usb.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/__eda
    ../../../vsf/kernel/__eda/: vsf_eda_bmpevt.c vsf_eda_queue.c vsf_eda_sync.c vsf_eda_timer.c
  group vsf/kernel/lib
    ../../../vsf/kernel/lib/: __kernel_lib_with_full_feature_set.h
  group vsf/kernel/shell
    ../../../vsf/kernel/shell/: vsf_shell.c vsf_shell.h
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmpevt.c vsf_simple_bmpevt.h vsf_simple_task.c
  group vsf/kernel/task
    ../../../vsf/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.c vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/osa_hal
    ../../../vsf/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
  group vsf/osa_service
    ../../../vsf/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group vsf/osa_service/msg_tree
    ../../../vsf/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/service
    ../../../vsf/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../vsf/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dystack
    ../../../vsf/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/fifo
    ../../../vsf/service/fifo/: vsf_fifo.c vsf_fifo.h
  group vsf/service/heap
    ../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../../vsf/service/json/: vsf_json.c vsf_json.h
  group vsf/service/pbuf
    ../../../vsf/service/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/pool
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/simple_stream
    ../../../vsf/service/simple_stream/: vsf_simple_stream.c vsf_simple_stream.h
  group vsf/service/simple_stream/block_stream
    ../../../vsf/service/simple_stream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group vsf/service/simple_stream/fifo_stream
    ../../../vsf/service/simple_stream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/simple_stream/mem_stream
    ../../../vsf/service/simple_stream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/service/stream
    ../../../vsf/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf_queue
    ../../../vsf/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/shell/sys/linux
    ../../../vsf/shell/sys/linux/: vsf_linux.c vsf_linux.h vsf_linux_cfg.h vsf_linux_socket.c
  group vsf/shell/sys/linux/include
    ../../../vsf/shell/sys/linux/include/: dirent.h errno.h fcntl.h libusb.h poll.h pthread.h semaphore.h signal.h stdio.h string.h termios.h time.h unistd.h wchar.h
  group vsf/shell/sys/linux/include/linux
    ../../../vsf/shell/sys/linux/include/linux/: limits.h
  group vsf/shell/sys/linux/include/sys
    ../../../vsf/shell/sys/linux/include/sys/: mount.h select.h stat.h time.h types.h wait.h
  group vsf/shell/sys/linux/lib/glibc
    ../../../vsf/shell/sys/linux/lib/glibc/: vsf_linux_glibc.c vsf_linux_glibc_pthread.c vsf_linux_glibc_sem.c vsf_linux_glibc_stdio.c vsf_linux_glibc_stdlib.c vsf_linux_glibc_string.c vsf_linux_glibc_time.c
  group vsf/shell/sys/linux/lib/libusb
    ../../../vsf/shell/sys/linux/lib/libusb/: vsf_linux_libusb.c
  group vsf/shell/sys/linux/port/busybox
    ../../../vsf/shell/sys/linux/port/busybox/: busybox.c busybox.h config.h
  group vsf/shell/sys/linux/port/busybox/shell
    ../../../vsf/shell/sys/linux/port/busybox/shell/: vsh.c
  group vsf/utilities
    ../../../vsf/utilities/: communicate.h compiler.h ooc_class.h
  group vsf/utilities/3rd-party/PLOOC/raw
    ../../../vsf/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h
  group vsf/utilities/compiler/__common
    ../../../vsf/utilities/compiler/__common/: __compiler.h __retarget_io.c __signal.h __type.h
  group vsf/utilities/compiler/arm
    ../../../vsf/utilities/compiler/arm/: arm_compiler.h retarget_io.c type.h
  group vsf/utilities/compiler/arm/CMSIS/Core/Include
    ../../../vsf/utilities/compiler/arm/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group vsf/utilities/compiler/arm/CMSIS/DSP/Include
    ../../../vsf/utilities/compiler/arm/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group vsf/utilities/compiler/arm/CMSIS/NN/Include
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group vsf/utilities/language_extension
    ../../../vsf/utilities/language_extension/: code_region.c code_region.h delegate.c delegate.h language_extension.h simple_sprintf.c simple_sscanf.c
  group vsf/utilities/preprocessor
    ../../../vsf/utilities/preprocessor/: mf_u8_dec2str.h mrepeat.h preprocessor.h tpaste.h
  group vsf/utilities/template
    ../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
  group vsf_private
    ../../../vsf_private/: user_vsf.h
  group vsf_private/hal/driver/GigaDevice
    ../../../vsf_private/hal/driver/GigaDevice/: driver.h
  group vsf_private/hal/driver/GigaDevice/GD32E10X
    ../../../vsf_private/hal/driver/GigaDevice/GD32E10X/: __device.h device.h driver.c driver.h jtag.c jtag.h swd.c swd.h timestamp.c timestamp.h
  group vsf_private/hal/driver/GigaDevice/GD32E10X/common
    ../../../vsf_private/hal/driver/GigaDevice/GD32E10X/common/: __common.c __common.h dma.c dma.h flash.c flash.h io.c io.h spi.c spi.h startup_gd32e10x.c usart.c usart.h
  group vsf_private/hal/driver/GigaDevice/GD32E10X/common/usb
    ../../../vsf_private/hal/driver/GigaDevice/GD32E10X/common/usb/: usb.c usb.h usb_common.c usb_lv0.c
    ../../../vsf_private/hal/driver/GigaDevice/GD32E10X/common/usb/dc/: usbd.c usbd.h
    ../../../vsf_private/hal/driver/GigaDevice/GD32E10X/common/usb/hc/: usbh.c usbh.h
  group vsf_private/hal/driver/GigaDevice/GD32E10X/common/vendor
    ../../../vsf_private/hal/driver/GigaDevice/GD32E10X/common/vendor/Include/: gd32e10x.h gd32e10x_adc.h gd32e10x_bkp.h gd32e10x_can.h gd32e10x_crc.h gd32e10x_ctc.h gd32e10x_dac.h gd32e10x_dbg.h gd32e10x_dma.h gd32e10x_exmc.h gd32e10x_exti.h gd32e10x_fmc.h gd32e10x_fwdgt.h gd32e10x_gpio.h gd32e10x_i2c.h gd32e10x_misc.h gd32e10x_pmu.h gd32e10x_rcu.h gd32e10x_rtc.h gd32e10x_spi.h gd32e10x_timer.h gd32e10x_usart.h gd32e10x_wwdgt.h
  group vsf_private/hal/driver/GigaDevice/GD32F3X0
    ../../../vsf_private/hal/driver/GigaDevice/GD32F3X0/: __device.h device.h driver.c driver.h jtag.c jtag.h swd.c swd.h timestamp.c timestamp.h
  group vsf_private/hal/driver/GigaDevice/GD32F3X0/common
    ../../../vsf_private/hal/driver/GigaDevice/GD32F3X0/common/: __common.c __common.h dma.c dma.h flash.c flash.h io.c io.h spi.c spi.h startup_gd32f3x0.c usart.c usart.h
  group vsf_private/hal/driver/GigaDevice/GD32F3X0/common/usb
    ../../../vsf_private/hal/driver/GigaDevice/GD32F3X0/common/usb/: usb.c usb.h usb_common.c usb_lv0.c
    ../../../vsf_private/hal/driver/GigaDevice/GD32F3X0/common/usb/dc/: usbd.c usbd.h
    ../../../vsf_private/hal/driver/GigaDevice/GD32F3X0/common/usb/hc/: usbh.c usbh.h
  group vsf_private/hal/driver/GigaDevice/GD32F3X0/common/vendor
    ../../../vsf_private/hal/driver/GigaDevice/GD32F3X0/common/vendor/Include/: gd32f3x0.h gd32f3x0_adc.h gd32f3x0_cec.h gd32f3x0_cmp.h gd32f3x0_crc.h gd32f3x0_ctc.h gd32f3x0_dac.h gd32f3x0_dbg.h gd32f3x0_dma.h gd32f3x0_exti.h gd32f3x0_fmc.h gd32f3x0_fwdgt.h gd32f3x0_gpio.h gd32f3x0_i2c.h gd32f3x0_misc.h gd32f3x0_pmu.h gd32f3x0_rcu.h gd32f3x0_rtc.h gd32f3x0_spi.h gd32f3x0_syscfg.h gd32f3x0_timer.h gd32f3x0_tsi.h gd32f3x0_usart.h gd32f3x0_wwdgt.h
  group vsf_private/ptshell
    ../../../vsf_private/ptshell/: vsf_ptshell.c vsf_ptshell.h
